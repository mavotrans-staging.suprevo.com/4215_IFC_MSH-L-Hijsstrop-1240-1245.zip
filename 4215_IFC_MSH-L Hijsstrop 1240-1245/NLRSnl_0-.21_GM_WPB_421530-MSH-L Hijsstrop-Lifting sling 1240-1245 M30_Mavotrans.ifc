Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], ExchangeRequirement []
File name: Project Number
Time: 2022-10-06T11:01:33
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190108_1515(x64) - Exporter 19.5.0.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Oct 06 11:01:33 2022 * Host: HPZ2-TPLAT * Database: C:\Users\TESSAP~1\AppData\Local\Temp\{631B45F2-EFD7-457D-85B3-35A2832FF50A}\ifc * Database version: 5507 * Database creation date: Thu Oct 06 11:01:32 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Oct 06 11:01:33 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Oct 06 11:01:33 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information
Other - BCB_ProjectFolder: C:\Users\Tessa Plat\OneDrive - Mavotrans\BIM T&D\3. Modellen Mavotrans\6. Bevestigen, hijsen en monteren\42-Hijsankersysteem - ''Hijsmiddelen''; Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; BCB_ProjectFolder: C:\Users\Tessa Plat\OneDrive - Mavotrans\BIM T&D\3. Modellen Mavotrans\6. Bevestigen, hijsen en monteren\42-Hijsankersysteem - ''Hijsmiddelen''; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey: Level:Circle Head - Project Datum, Level 0
LongName: Level 0; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: Circle Head - Project Datum
Pset_AirSideSystemInformation - Name: Level 0
Pset_ProductRequirements - Name: Level 0; Category: Levels
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 0; Structural: no
Other - Category: Levels; Family: Level: Circle Head - Project Datum; Family and Type: Level: Circle Head - Project Datum; Type: Level: Circle Head - Project Datum; Type Id: Level: Circle Head - Project Datum
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: Anno_Level_Head_Circle: Standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: no

# IfcBuildingElementProxy: NLRSnl_0-.21_GM_WPB_4215-MSH-L Hijsstrop-Lifting sling 1240-1245_Mavotrans_R19:421530_M30, 421530
In: Level 0
Type - Material: Stainless Steel AISI 304
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - d_nom: M30; e (mm): 35 mm
Type - Fire Protection - Brandwerendheid | Fire resistance rating: Niet getest | Not rated
Type - Forces - 0 - 9° (kN): 60 mm; 10 - 30° (kN): 57 mm; 31 - 45° (kN): 45 mm; 46 - 90° (kN): 30 mm
Type - Identity Data - Artikelnummer | Article number: 421530; Beschrijving | Description: Hijsstrop | Lifting sling M30; Certificaten | Certification: CE; Laatste versie | Last version: 06-10-2022; Leverancier | Supplier: Mavotrans; Model: LOD400; NL-SfB code: 0-.21; Opmerkingen | Comments: Geschikt voor rechtstandig hijsen en hijsen onder een hoek tot 45° en kantelen | Suitable for upright lifting and lifting at an angle up to 45° and tilt; Revisie | Revision: Rev0; Technische data | Technical data: Raadpleeg de gekoppelde webpagina | Please refer to linked URL; Tekenaar | Draftsman: D. Blokland; Type Comments: M10, M36 en M42 op aanvraag leverbaar | M10, M36 en M42 available on request; Type Name: 421530_M30; URL: https://mavotrans.nl/msh-s-hijsstrop-1240-1245.html; Verpakkingshoeveelheid | Sales packaging: Verpakt per stuk | Sold per piece
Type - Materials and Finishes - Materiaal | Material: Staal | Steel
Type - Other - Category: Generic Models; Diameter: 30 mm; e: 35 mm; Family Name: NLRSnl_0-.21_GM_WPB_4215-MSH-L Hijsstrop-Lifting sling 1240-1245_Mavotrans_R19
Type - Pset_ProductRequirements - Category: Generic Models
Type - Pset_ProvisionForVoid - Diameter: 30 mm
Description: Hijsstrop | Lifting sling M30; Classification: 0-.21 (Default Classification)
Pset_BuildingElementProxyCommon - Reference: NLRSnl_0-.21_GM_WPB_4215-MSH-L Hijsstrop-Lifting sling 1240-1245_Mavotrans_R19:421530_M30; sets with these values: 2
Constraints - Level: Level: Level 0; Offset: 0 mm; Work Plane: Level : Level 0
Dimensions - Area: 0.0551441 m2; Volume: 0.000522438 m3
Other - Family: NLRSnl_0-.21_GM_WPB_4215-MSH-L Hijsstrop-Lifting sling 1240-1245_Mavotrans_R19: 421530_M30; Family and Type: NLRSnl_0-.21_GM_WPB_4215-MSH-L Hijsstrop-Lifting sling 1240-1245_Mavotrans_R19: 421530_M30; Schedule Level: Level: Level 0; Type: NLRSnl_0-.21_GM_WPB_4215-MSH-L Hijsstrop-Lifting sling 1240-1245_Mavotrans_R19: 421530_M30; Type Id: NLRSnl_0-.21_GM_WPB_4215-MSH-L Hijsstrop-Lifting sling 1240-1245_Mavotrans_R19: 421530_M30
Phasing - Phase Created: New Construction
